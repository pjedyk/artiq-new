require recipes-core/images/petalinux-image-common.inc
