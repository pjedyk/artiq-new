inherit packagegroup

RDEPENDS:${PN} = " \
  artiq-cored \
"
